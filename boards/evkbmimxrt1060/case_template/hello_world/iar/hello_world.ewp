# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1062DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../fat_src; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: hello_world.srec
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; CPU_MIMXRT1062DVL6B_cm7; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group source
    ../../../../fat_src/: fat.c fat.h
    ../: hello_world.c
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
